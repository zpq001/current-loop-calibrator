# Keil uVision project CurrentLoopCalibrator.uvprojx, settings and files
target Target FLASH (ARM-ADS)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.3.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CurrentLoopCalibrator +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_MDR1986VE9x
  c include: ..\library\CMSIS\CM3\CoreSupport;..\library\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc;..\library\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup\arm;..\library\MDR32F9Qx_StdPeriph_Driver\inc;..\source\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Core support
    ../library/CMSIS/CM3/CoreSupport/: core_cm3.c
  group Device support
    ../library/CMSIS/CM3/DeviceSupport/MDR32F9Qx/startup/arm/: system_MDR32F9Qx.c startup_MDR32F9Qx.s
  group Std Periph Driver
    ../library/MDR32F9Qx_StdPeriph_Driver/src/: MDR32F9Qx_port.c MDR32F9Qx_rst_clk.c
  group include
    ../source/inc/: MDR32F9Qx_config.h dwt_delay.h lcd_melt20s4.h lcd_melt.h buttons.h led.h encoder.h dac.h
  group source
    ../source/src/: main.c hw_utils.c dwt_delay.c lcd_melt20s4.c buttons.c led.c encoder.c dac.c
target Target_RAM (ARM-ADS)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.3.0
  cpu: as above
  output: CurrentLoopCalibrator +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
